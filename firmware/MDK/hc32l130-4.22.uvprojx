# Keil uVision project hc32l130-4.22.uvprojx, settings and files
target gpio_output_Release (6070000::V6.7::.\ARMCLANG)
  device: HC32L130J8TA HDSC
  pack: HDSC.HC32L13x.1.2.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: gpio_output +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\source;..\driver\inc;..\user;..\mcu\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l13x.s
    ../mcu/common/: system_hc32l13x.c interrupts_hc32l13x.c
  group source
    ../source/: main.c
  group driver
    ../driver/src/: ddl.c sysctrl.c gpio.c adc.c bt.c lpm.c reset.c uart.c wdt.c flash.c lptim.c rtc.c i2c.c lpuart.c bgr.c
  group README
    ../: readme.txt
  group user
    ../user/: 8266.c MyFlash.c MyGPIO.c MyUART.c Timer0.c sht30i2c.c sht30.c MyADC.C
software components: CMSIS:CORE 5.2.0
